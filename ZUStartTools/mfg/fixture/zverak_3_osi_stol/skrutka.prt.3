# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 2.0 (M090) (file skrutka.prt.3)

Parameters:
  PDMRL = "Initial"
  PDMREV = "1.0+"