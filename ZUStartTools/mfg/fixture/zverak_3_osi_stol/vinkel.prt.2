# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 2.0 (M090) (file vinkel.prt.2)

Parameters:
  WERKSTOFF = "St37"

Other parameters: MASSE