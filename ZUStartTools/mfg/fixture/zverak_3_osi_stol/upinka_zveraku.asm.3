# Pro/ENGINEER assembly, saved by Pro/ENGINEER Wildfire 2.0 (M090) (file upinka_zveraku.asm.3)

Other parameters: MASSE