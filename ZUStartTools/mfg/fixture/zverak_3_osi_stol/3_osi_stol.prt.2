# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 2.0 (M090) (file 3_osi_stol.prt.2)

Parameters:
  WERKSTOFF = "St37"

Other parameters: MASSE