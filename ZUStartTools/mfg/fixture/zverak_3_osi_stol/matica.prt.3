# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 2.0 (M090) (file matica.prt.3)

Parameters:
  PDMRL = "Initial"
  PDMREV = "1.0+"