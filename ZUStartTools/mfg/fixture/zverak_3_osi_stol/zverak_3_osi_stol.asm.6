# Pro/ENGINEER assembly, saved by Pro/ENGINEER Wildfire 2.0 (M090) (file zverak_3_osi_stol.asm.6)

Other parameters: MASSE