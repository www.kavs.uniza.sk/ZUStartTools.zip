# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 2.0 (M090) (file vlozka_svorky.prt.1)

Other parameters: D7, D9