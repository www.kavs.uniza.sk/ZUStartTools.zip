# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 2.0 (M090) (file telo_svorky.prt.1)

Other parameters: D6